# Keil uVision project Autogenerated_Controller.uvprojx, settings and files
target Autogenerated_Controller (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F746IGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.9.0
  cpu: IROM(0x08000000-0x080FFFFF) IRAM(0x20000000-0x2004FFFF) CLOCK(12000000) FPU3(SFPU) ELITTLE CPUTYPE("Cortex-M7")
  output: Autogenerated_Controller
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F746xx
  c include: ../Inc;../Drivers/STM32F7xx_HAL_Driver/Inc;../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Include;../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../../../Libs/C;..\acado;..\acado\qpoases;..\acado\qpoases\INCLUDE;..\acado\qpoases\SRC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  link misc: --diag_suppress=L6329 --datacompressor=0
  group Application/User
    ../Src/: stm32f7xx_it.c stm32f7xx_hal_msp.c low_lvl_main.c main_mpc.c
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_tim_ex.c stm32f7xx_hal.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_cortex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_tim.c stm32f7xx_hal_gpio.c stm32f7xx_hal_i2c.c stm32f7xx_hal_dac_ex.c stm32f7xx_hal_dac.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_uart.c
  group Drivers/CMSIS
    ../Drivers/CMSIS//Device/ST/STM32F7xx/Source/Templates/: system_stm32f7xx.c
  group Application/MDK-ARM
    ./: startup_stm32f746xx.s
  group acado
    ../acado/: acado_integrator.c acado_solver.c
  group qpoases
    ../acado/qpoases/SRC/: Utils.cpp SubjectTo.cpp QProblemB.cpp QProblem.cpp MessageHandling.cpp Indexlist.cpp CyclingManager.cpp Constraints.cpp Bounds.cpp
    ../acado/: acado_qpoases_interface.cpp
software components: CMSIS:CORE 4.1.0
