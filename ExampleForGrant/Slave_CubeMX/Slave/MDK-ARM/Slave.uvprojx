# Keil uVision project Slave.uvprojx, settings and files
target Slave (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(SFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: Slave
  BeforeMake: C:\Users\Admin\Documents\GitHub\Cpp\Kompilator_skrosny\main.exe -I -i ../Src/main.mpc -o ../Src/main_mpc.c -l ../../../../Libs/MATLAB/ -L ../../../../Libs/C/
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F746xx
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F7xx_HAL_Driver/Inc;../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../Drivers/CMSIS/Include;../../../../Libs/C;../QP_wersja_float
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  link misc: --diag_suppress=L6329
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_flash_ex.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_flash.c stm32f7xx_hal_i2c.c stm32f7xx_hal_adc.c stm32f7xx_hal_gpio.c stm32f7xx_hal_cortex.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_tim.c stm32f7xx_hal_dma.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c
  group Application/MDK-ARM
    ./: startup_stm32f746xx.s
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Application/User
    ../Src/: stm32f7xx_hal_msp.c stm32f7xx_it.c low_lvl_main.c mat_lib.c main_mpc.c
    ../../../../Libs/C/: default_functions.c main.c mpctools.c profiler.c simulated_signals.c
    ../QP_wersja_float/: alokacja_nr.c obl_macierzowe.c pk.c
software components: CMSIS:CORE 4.1.0
